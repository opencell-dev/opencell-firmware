#include "oc_oled.h"

#include <string.h>

/* Classic 5x7 font, ASCII 0x20..0x5F, column bytes (LSB = top row). */
static const uint8_t k_font[64][5] = {
    { 0x00, 0x00, 0x00, 0x00, 0x00 }, { 0x00, 0x00, 0x5F, 0x00, 0x00 }, /* space ! */
    { 0x00, 0x07, 0x00, 0x07, 0x00 }, { 0x14, 0x7F, 0x14, 0x7F, 0x14 }, /* " # */
    { 0x24, 0x2A, 0x7F, 0x2A, 0x12 }, { 0x23, 0x13, 0x08, 0x64, 0x62 }, /* $ % */
    { 0x36, 0x49, 0x55, 0x22, 0x50 }, { 0x00, 0x05, 0x03, 0x00, 0x00 }, /* & ' */
    { 0x00, 0x1C, 0x22, 0x41, 0x00 }, { 0x00, 0x41, 0x22, 0x1C, 0x00 }, /* ( ) */
    { 0x08, 0x2A, 0x1C, 0x2A, 0x08 }, { 0x08, 0x08, 0x3E, 0x08, 0x08 }, /* * + */
    { 0x00, 0x50, 0x30, 0x00, 0x00 }, { 0x08, 0x08, 0x08, 0x08, 0x08 }, /* , - */
    { 0x00, 0x60, 0x60, 0x00, 0x00 }, { 0x20, 0x10, 0x08, 0x04, 0x02 }, /* . / */
    { 0x3E, 0x51, 0x49, 0x45, 0x3E }, { 0x00, 0x42, 0x7F, 0x40, 0x00 }, /* 0 1 */
    { 0x42, 0x61, 0x51, 0x49, 0x46 }, { 0x21, 0x41, 0x45, 0x4B, 0x31 }, /* 2 3 */
    { 0x18, 0x14, 0x12, 0x7F, 0x10 }, { 0x27, 0x45, 0x45, 0x45, 0x39 }, /* 4 5 */
    { 0x3C, 0x4A, 0x49, 0x49, 0x30 }, { 0x01, 0x71, 0x09, 0x05, 0x03 }, /* 6 7 */
    { 0x36, 0x49, 0x49, 0x49, 0x36 }, { 0x06, 0x49, 0x49, 0x29, 0x1E }, /* 8 9 */
    { 0x00, 0x36, 0x36, 0x00, 0x00 }, { 0x00, 0x56, 0x36, 0x00, 0x00 }, /* : ; */
    { 0x00, 0x08, 0x14, 0x22, 0x41 }, { 0x14, 0x14, 0x14, 0x14, 0x14 }, /* < = */
    { 0x41, 0x22, 0x14, 0x08, 0x00 }, { 0x02, 0x01, 0x51, 0x09, 0x06 }, /* > ? */
    { 0x32, 0x49, 0x79, 0x41, 0x3E }, { 0x7E, 0x11, 0x11, 0x11, 0x7E }, /* @ A */
    { 0x7F, 0x49, 0x49, 0x49, 0x36 }, { 0x3E, 0x41, 0x41, 0x41, 0x22 }, /* B C */
    { 0x7F, 0x41, 0x41, 0x22, 0x1C }, { 0x7F, 0x49, 0x49, 0x49, 0x41 }, /* D E */
    { 0x7F, 0x09, 0x09, 0x01, 0x01 }, { 0x3E, 0x41, 0x41, 0x51, 0x32 }, /* F G */
    { 0x7F, 0x08, 0x08, 0x08, 0x7F }, { 0x00, 0x41, 0x7F, 0x41, 0x00 }, /* H I */
    { 0x20, 0x40, 0x41, 0x3F, 0x01 }, { 0x7F, 0x08, 0x14, 0x22, 0x41 }, /* J K */
    { 0x7F, 0x40, 0x40, 0x40, 0x40 }, { 0x7F, 0x02, 0x04, 0x02, 0x7F }, /* L M */
    { 0x7F, 0x04, 0x08, 0x10, 0x7F }, { 0x3E, 0x41, 0x41, 0x41, 0x3E }, /* N O */
    { 0x7F, 0x09, 0x09, 0x09, 0x06 }, { 0x3E, 0x41, 0x51, 0x21, 0x5E }, /* P Q */
    { 0x7F, 0x09, 0x19, 0x29, 0x46 }, { 0x46, 0x49, 0x49, 0x49, 0x31 }, /* R S */
    { 0x01, 0x01, 0x7F, 0x01, 0x01 }, { 0x3F, 0x40, 0x40, 0x40, 0x3F }, /* T U */
    { 0x1F, 0x20, 0x40, 0x20, 0x1F }, { 0x7F, 0x20, 0x18, 0x20, 0x7F }, /* V W */
    { 0x63, 0x14, 0x08, 0x14, 0x63 }, { 0x03, 0x04, 0x78, 0x04, 0x03 }, /* X Y */
    { 0x61, 0x51, 0x49, 0x45, 0x43 }, { 0x00, 0x00, 0x7F, 0x41, 0x41 }, /* Z [ */
    { 0x02, 0x04, 0x08, 0x10, 0x20 }, { 0x41, 0x41, 0x7F, 0x00, 0x00 }, /* \ ] */
    { 0x04, 0x02, 0x01, 0x02, 0x04 }, { 0x40, 0x40, 0x40, 0x40, 0x40 }, /* ^ _ */
};

void oc_oled_clear(uint8_t *fb)
{
    memset(fb, 0, OC_OLED_FB);
}

static const uint8_t *glyph(char ch)
{
    unsigned char c = (unsigned char)ch;
    if (c >= 'a' && c <= 'z') {
        c = (unsigned char)(c - 'a' + 'A');
    }
    if (c < 0x20 || c > 0x5F) {
        c = '?';
    }
    return k_font[c - 0x20];
}

void oc_oled_text(uint8_t *fb, uint8_t page, uint8_t col, const char *s)
{
    if (page >= OC_OLED_PAGES) {
        return;
    }
    for (; *s != '\0' && col < OC_OLED_COLS; s++, col++) {
        uint8_t *dst = fb + (size_t)page * OC_OLED_W + (size_t)col * 6u;
        memcpy(dst, glyph(*s), 5);
        dst[5] = 0;
    }
}

/* Each bit of a 7-row glyph column becomes two rows: 0..13 of a 16-bit column. */
static uint16_t stretch(uint8_t col)
{
    uint16_t out = 0;
    for (int b = 0; b < 8; b++) {
        if (col & (1u << b)) {
            out |= (uint16_t)(3u << (2 * b));
        }
    }
    return out;
}

void oc_oled_text_x2(uint8_t *fb, uint8_t page, uint8_t x, const char *s)
{
    if (page + 1u >= OC_OLED_PAGES) {
        return;
    }
    uint8_t *top = fb + (size_t)page * OC_OLED_W;
    uint8_t *bot = top + OC_OLED_W;
    for (unsigned px = x; *s != '\0'; s++) {
        const uint8_t *g = glyph(*s);
        for (int i = 0; i < 6; i++) { /* 5 glyph columns + 1 gap, each drawn twice */
            uint16_t v = i < 5 ? stretch(g[i]) : 0;
            for (int rep = 0; rep < 2; rep++, px++) {
                if (px >= OC_OLED_W) {
                    return;
                }
                top[px] = (uint8_t)v;
                bot[px] = (uint8_t)(v >> 8);
            }
        }
    }
}

void oc_oled_render_lines(uint8_t *fb, const char lines[][OC_OLED_COLS + 1], uint8_t n)
{
    oc_oled_clear(fb);
    for (uint8_t i = 0; i < n; i++) {
        uint8_t page = i == 0 ? 0u : (uint8_t)(i + 1u);
        if (page >= OC_OLED_PAGES) {
            break;
        }
        oc_oled_text(fb, page, 0, lines[i]);
    }
}
